# Keil uVision project WaterBall.uvprojx, settings and files
target nrf51422_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WaterBall_$GITVERSION_$_$GITMODCOUNT$ +hex
  BeforeMake: "..\Tools\GitVersionNumbers\GitVersionNumbers.exe" -s ".." -f "version.h.git"
  AfterMake: "..\Tools\GitVersionNumbers\GitVersionNumbers.exe" -s ".." -f "Objects\WaterBall_$GITVERSION_$_$GITMODCOUNT$.hex" -rn -c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_DEFINES_ONLY BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 DEBUG SWI_DISABLE0
  c include: .;..\Config;..\nRF5_SDK\components\ble\common;..\nRF5_SDK\components\drivers_nrf\clock;..\nRF5_SDK\components\drivers_nrf\common;..\nRF5_SDK\components\drivers_nrf\delay;..\nRF5_SDK\components\drivers_nrf\gpiote;..\nRF5_SDK\components\drivers_nrf\hal;..\nRF5_SDK\components\drivers_nrf\twi_master;..\nRF5_SDK\components\drivers_nrf\uart;..\nRF5_SDK\components\libraries\button;..\nRF5_SDK\components\libraries\fifo;..\nRF5_SDK\components\libraries\timer;..\nRF5_SDK\components\libraries\twi;..\nRF5_SDK\components\libraries\uart;..\nRF5_SDK\components\libraries\util;..\nRF5_SDK\components\softdevice\common\softdevice_handler;..\nRF5_SDK\components\softdevice\s130\headers;..\nRF5_SDK\examples\bsp
  asm define: BSP_DEFINES_ONLY BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002670 size 0x5990
  group Application
    ./: advertise.c ble_stack.c buttons.c clock.c connect.c discovery.c game.c i2c.c main.c serial.c service.c service_client.c service_server.c seven_segment.c status.c
  group nRF_BLE
    ../nRF5_SDK/components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../nRF5_SDK/components/drivers_nrf/delay/: nrf_delay.c
    ../nRF5_SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../nRF5_SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nRF5_SDK/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../nRF5_SDK/components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../nRF5_SDK/components/libraries/button/: app_button.c
    ../nRF5_SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../nRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK/components/libraries/timer/: app_timer.c
    ../nRF5_SDK/components/libraries/uart/: app_uart_fifo.c
    ../nRF5_SDK/components/libraries/twi/: app_twi.c
  group nRF_SoftDevice
    ../nRF5_SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../nRF5_SDK/components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
