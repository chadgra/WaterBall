# Keil uVision project Bootloader.uvprojx, settings and files
target nrf51422_xxac_debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader_debug +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S130 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 DFU_APP_DATA_RESERVED=2048
  c include: .\;..\Config;..\nRF5_SDK\components\ble\ble_services\ble_dfu;..\nRF5_SDK\components\ble\common;..\nRF5_SDK\components\drivers_nrf\common;..\nRF5_SDK\components\drivers_nrf\delay;..\nRF5_SDK\components\drivers_nrf\gpiote;..\nRF5_SDK\components\drivers_nrf\hal;..\nRF5_SDK\components\drivers_nrf\pstorage;..\nRF5_SDK\components\libraries\bootloader_dfu;..\nRF5_SDK\components\libraries\button;..\nRF5_SDK\components\libraries\crc16;..\nRF5_SDK\components\libraries\hci;..\nRF5_SDK\components\libraries\pwm;..\nRF5_SDK\components\libraries\scheduler;..\nRF5_SDK\components\libraries\timer;..\nRF5_SDK\components\libraries\util;..\nRF5_SDK\components\softdevice\common\softdevice_handler;..\nRF5_SDK\components\softdevice\s130\headers;..\nRF5_SDK\components\softdevice\s130\headers\nrf51;..\nRF5_SDK\components\toolchain;..\nRF5_SDK\examples\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x5380
  memory RVCT10: RAM 0x20007f80 size 0x80
  group Application
    ./: dfu_ble_svc.c main.c dfu_transport_ble_custom.c
  group Documentation
    ./: Abstract.txt license.txt
  group nRF_BLE
    ../nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../nRF5_SDK/components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../nRF5_SDK/components/drivers_nrf/delay/: nrf_delay.c
    ../nRF5_SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nRF5_SDK/components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    ../nRF5_SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../nRF5_SDK/components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_dual_bank.c dfu_init_template.c
    ../nRF5_SDK/components/libraries/crc16/: crc16.c
    ../nRF5_SDK/components/libraries/hci/: hci_mem_pool.c
  group nRF_SoftDevice
    ../nRF5_SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
    ../nRF5_SDK/components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
target nrf51822_xxac_production (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: Bootloader_production +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_CUSTOM S130 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 DFU_APP_DATA_RESERVED=2048
  c include: .\;..\Config;..\nRF51_SDK\components\ble\ble_services\ble_dfu;..\nRF51_SDK\components\ble\common;..\nRF51_SDK\components\drivers_nrf\common;..\nRF51_SDK\components\drivers_nrf\delay;..\nRF51_SDK\components\drivers_nrf\gpiote;..\nRF51_SDK\components\drivers_nrf\hal;..\nRF51_SDK\components\drivers_nrf\pstorage;..\nRF51_SDK\components\libraries\bootloader_dfu;..\nRF51_SDK\components\libraries\button;..\nRF51_SDK\components\libraries\crc16;..\nRF51_SDK\components\libraries\hci;..\nRF51_SDK\components\libraries\pwm;..\nRF51_SDK\components\libraries\scheduler;..\nRF51_SDK\components\libraries\timer;..\nRF51_SDK\components\libraries\util;..\nRF51_SDK\components\softdevice\common\softdevice_handler;..\nRF51_SDK\components\softdevice\s130\headers;..\nRF51_SDK\components\softdevice\s130\headers\nrf51;..\nRF51_SDK\components\toolchain;..\nRF51_SDK\examples\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x5380
  memory RVCT10: RAM 0x20007f80 size 0x80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
